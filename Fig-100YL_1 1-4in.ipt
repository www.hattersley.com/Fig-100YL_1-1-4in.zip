# Autodesk Inventor part: 100YL-114
## iProperties
Created: 2011-01
Part Number: 100YL-114
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
